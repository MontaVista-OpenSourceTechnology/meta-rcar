EXTRA_OEMAKE += "CONFIG_P2P=1 CONFIG_WIFI_DISPLAY=1"
