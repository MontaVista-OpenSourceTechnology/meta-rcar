RCONFLICTS:${PN} += "libnss-mdns"
RPROVIDES:${PN} += "libnss-mdns"
